FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-handle-mount-namespace-readlink-errors.patch"
