FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"

SRC_URI += "file://0001-modesetting-fix-CTM-identity-on-32-bit.patch"
