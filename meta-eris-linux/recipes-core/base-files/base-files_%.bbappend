#
# `base-files_%.bbappend`
#
# (c) 2024-2026 Logilin.
#

# Add `/data` directory on the target.

dirs755:append = " /data"

