
FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
