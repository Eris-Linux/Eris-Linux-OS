
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://fragment.cfg"
SRC_URI += "file://device-mapper-fragment.cfg"


