## meta-eris-linux-raspberrypi/conf/distro/eris-linux-headless-rpi2.conf
```bitbake
require eris-linux-headless-distro.confg

DISTRO_FEATURES:remove = "virtualization"
```
