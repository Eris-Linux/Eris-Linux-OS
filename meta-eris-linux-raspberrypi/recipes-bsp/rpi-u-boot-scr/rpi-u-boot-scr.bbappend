
# Avoid any actions from rpi-u-boot-scr recipe.

do_compile() {
}

do_deploy() {
}

