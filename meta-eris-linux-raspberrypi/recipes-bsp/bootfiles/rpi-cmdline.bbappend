
CMDLINE_ROOTFS = "rootfstype=ext4 rootwait"
CMDLINE += "loglevel=0"
