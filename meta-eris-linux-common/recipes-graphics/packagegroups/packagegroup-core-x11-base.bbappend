
RDEPENDS:${PN}:remove = "matchbox-terminal"
RDEPENDS:${PN}:remove = "matchbox-wm"

